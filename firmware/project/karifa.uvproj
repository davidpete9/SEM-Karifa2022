# Keil uVision project karifa.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: karifa +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: animation.c animation.h led.c led.h main.c persist.c persist.h platform.h STARTUP.A51 stc8g.h stc8h.h types.h util.c util.h rgbled.c rgbled.h
